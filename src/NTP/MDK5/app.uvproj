# Keil uVision project app.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: W7200 WIZnet
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: app +hex
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --vhx --8x1 --output main.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ..\User;..\W7500P_driver\CMSIS\Device\WIZnet\W7500\Include;..\W7500P_driver\CMSIS\Device\WIZnet\W7500\Source\ARM;..\W7500P_driver\W7500x_stdPeriph_Driver\inc;..\W7500P_driver\W7500x_stdPeriph_Driver\src;..\ioLibary\Ethernet;..\ioLibary\MDIO;..\output;..\Applications;..\W7500P_driver\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../User/: main.c retarget.c W7500x_conf.h bsp_uart.c bsp_uart.h ip_config.c ip_config.h time_delay.c time_delay.h W7500x_it.c W7500x_it.h
  group driver
    ../W7500P_driver/W7500x_stdPeriph_Driver/src/: W7500x_crg.c W7500x_gpio.c W7500x_uart.c W7500x_wztoe.c
  group system
    ../W7500P_driver/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
    ../W7500P_driver/CMSIS/Device/WIZnet/W7500/Include/: system_W7500x.h
    ../W7500P_driver/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group iolibary
    ../ioLibary/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
    ../ioLibary/MDIO/: W7500x_miim.c W7500x_miim.h
  group application
    ../Applications/: ntp.c ntp.h
